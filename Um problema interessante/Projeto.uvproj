# Keil uVision project Projeto.uvproj, settings and files
target Target 1 (MCS-51)
  device: 80C51FA Intel
  cpu: IRAM(0-0xFF) CLOCK(20000000)
  output: ProjConcorrencia
  c flags: SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 exemplo.c
