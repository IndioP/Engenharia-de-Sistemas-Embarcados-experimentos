# Keil uVision project proj5.uvproj, settings and files
target Target 1 (MCS-51)
  device: 8XC52 NXP
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: proj5
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c
